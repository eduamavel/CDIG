options:
  parameters:
    generate_options: qt_gui
    id: OFDM_Receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_0
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', '' 8.5 | 2449.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2451000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 2484000000, 5170000000, 5180000000, 5190000000, 5200000000, 5210000000, 5220000000, 5230000000, 5240000000, 5250000000, 5260000000, 5270000000, 5280000000, 5290000000, 5300000000, 5310000000, 5320000000, 5500000000, 5510000000, 5520000000, 5530000000, 5540000000, 5550000000, 5560000000, 5570000000, 5580000000, 5590000000, 5600000000, 5610000000, 5620000000, 5630000000, 5640000000, 5660000000, 5670000000, 5680000000, 5690000000, 5700000000, 5710000000, 5720000000, 5745000000, 5755000000, 5765000000, 5775000000, 5785000000, 5795000000, 5805000000, 5825000000, 5860000000, 5870000000, 5880000000, 5890000000, 5900000000, 5910000000, 5920000000]'
    type: real
    value: '2437000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5000000, 10000000, 20000000]'
    type: real
    value: '20000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Threshold
    start: '0'
    step: '0.050'
    stop: '1'
    value: '0.50'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/c/Users/pedro/Desktop/wireshark.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /mnt/c/Users/pedro/Desktop/wireshark.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pedro/gnuradio_sdr/Sample3_20MHz_Channel100.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '127'
  states: {state: disabled}
- name: foo_wireshark_connector_1
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: 20e6
    debug: 'False'
    freq: freq_0
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_parse_mac_1
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: threshold
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_0
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '12345'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '12345'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_2
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '12345'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_3
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '12345'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_4
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '12345'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '380'
    type: complex
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Autocorrelation normalized"'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0000005'
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '64'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_1, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [fft_vxx_1, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '1']
- [fir_filter_xxx_1, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_1, '0', ieee802_11_sync_short_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [foo_wireshark_connector_1, '0', blocks_file_sink_1, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_1, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_1, out, foo_wireshark_connector_0, in]
- [ieee802_11_parse_mac_1, out, foo_wireshark_connector_1, in]
- [ieee802_11_parse_mac_1, out, network_socket_pdu_4, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_1, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_socket_pdu_4, pdus, blocks_message_debug_0, log]
- [network_socket_pdu_4, pdus, blocks_message_debug_0, print]
- [network_socket_pdu_4, pdus, blocks_message_debug_0, print_pdu]
- [network_socket_pdu_4, pdus, blocks_message_debug_0, store]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
